# Keil uVision project RUSSIA.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RUSSIA
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\HARDWARE\LED;.\HARDWARE\LCD;.\HARDWARE\KEY;.\HARDWARE\ITEMP;.\HARDWARE\ADC;.\RTE\Device\STM32F103RC;.\RTE;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\REMOTE;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group src
    ./: main.c
  group hw
    ./HARDWARE/ADC/: adc.c
    ./HARDWARE/ITEMP/: tsensor.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/REMOTE/: remote.c
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/TOUCH/: touch.c ott2001a.c gt9147.c ft5206.c ctiic.c
  group sys
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
software components: CMSIS:CORE 3.40.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
